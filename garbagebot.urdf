Commit message: Add files via upload

File: garbagebot.urdf (robot description, URDF)
Before this commit: robot trashbot, 6 links, 4 joints
Joints:
- added joint caster_back_right_joint: type fixed, parent base_link, child caster_back_right_link, origin xyz=-0.177 -0.064 -0.004 rpy=-1.57 0 0
